/*
 * Driver toi gian cho man hinh OLED 0.96 inch (SSD1306, 128x64, giao tiep I2C)
 * Dung chung bus I2C voi BH1750 thong qua thu vien i2cdev (esp-idf-lib).
 *
 * Cach dung:
 *   static oled_t oled;
 *   oled_init(&oled, 0x3C, I2C_NUM_0, GPIO_NUM_8, GPIO_NUM_9);
 *   oled_clear(&oled);
 *   oled_printf(&oled, 0, "Nhiet do: %.1f C", temp);   // dong 0..7
 *   oled_flush(&oled);                                  // day du lieu ra man hinh
 *
 * Man hinh hien duoc 8 dong, moi dong 21 ky tu (font 5x7, ASCII 32..126).
 * Font khong ho tro chu co dau tieng Viet, nen ghi tieng Viet khong dau.
 */
#pragma once

#include <stdarg.h>
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include "i2cdev.h"

#define OLED_WIDTH   128
#define OLED_HEIGHT  64
#define OLED_LINES   (OLED_HEIGHT / 8)   // 8 dong (moi dong = 1 "page" cua SSD1306)
#define OLED_COLS    (OLED_WIDTH / 6)    // 21 ky tu moi dong (moi ky tu rong 6 pixel)

typedef struct {
    i2c_dev_t dev;
    uint8_t buf[OLED_WIDTH * OLED_LINES];   // bo nho dem 1024 byte
} oled_t;

// Font 5x7, 95 ky tu ASCII tu 32 (khoang trang) den 126 (~), moi ky tu 5 byte (5 cot)
static const uint8_t OLED_FONT_5X7[95 * 5] = {
    0x00, 0x00, 0x00, 0x00, 0x00,  // khoang trang
    0x00, 0x00, 0x5F, 0x00, 0x00,  // !
    0x00, 0x07, 0x00, 0x07, 0x00,  // dau nhay kep
    0x14, 0x7F, 0x14, 0x7F, 0x14,  // #
    0x24, 0x2A, 0x7F, 0x2A, 0x12,  // $
    0x23, 0x13, 0x08, 0x64, 0x62,  // %
    0x36, 0x49, 0x56, 0x20, 0x50,  // &
    0x00, 0x08, 0x07, 0x03, 0x00,  // dau nhay don
    0x00, 0x1C, 0x22, 0x41, 0x00,  // (
    0x00, 0x41, 0x22, 0x1C, 0x00,  // )
    0x2A, 0x1C, 0x7F, 0x1C, 0x2A,  // *
    0x08, 0x08, 0x3E, 0x08, 0x08,  // +
    0x00, 0x80, 0x70, 0x30, 0x00,  // ,
    0x08, 0x08, 0x08, 0x08, 0x08,  // -
    0x00, 0x00, 0x60, 0x60, 0x00,  // .
    0x20, 0x10, 0x08, 0x04, 0x02,  // /
    0x3E, 0x51, 0x49, 0x45, 0x3E,  // 0
    0x00, 0x42, 0x7F, 0x40, 0x00,  // 1
    0x72, 0x49, 0x49, 0x49, 0x46,  // 2
    0x21, 0x41, 0x49, 0x4D, 0x33,  // 3
    0x18, 0x14, 0x12, 0x7F, 0x10,  // 4
    0x27, 0x45, 0x45, 0x45, 0x39,  // 5
    0x3C, 0x4A, 0x49, 0x49, 0x31,  // 6
    0x41, 0x21, 0x11, 0x09, 0x07,  // 7
    0x36, 0x49, 0x49, 0x49, 0x36,  // 8
    0x46, 0x49, 0x49, 0x29, 0x1E,  // 9
    0x00, 0x00, 0x14, 0x00, 0x00,  // :
    0x00, 0x40, 0x34, 0x00, 0x00,  // ;
    0x00, 0x08, 0x14, 0x22, 0x41,  // <
    0x14, 0x14, 0x14, 0x14, 0x14,  // =
    0x00, 0x41, 0x22, 0x14, 0x08,  // >
    0x02, 0x01, 0x59, 0x09, 0x06,  // ?
    0x3E, 0x41, 0x5D, 0x59, 0x4E,  // @
    0x7C, 0x12, 0x11, 0x12, 0x7C,  // A
    0x7F, 0x49, 0x49, 0x49, 0x36,  // B
    0x3E, 0x41, 0x41, 0x41, 0x22,  // C
    0x7F, 0x41, 0x41, 0x41, 0x3E,  // D
    0x7F, 0x49, 0x49, 0x49, 0x41,  // E
    0x7F, 0x09, 0x09, 0x09, 0x01,  // F
    0x3E, 0x41, 0x41, 0x51, 0x73,  // G
    0x7F, 0x08, 0x08, 0x08, 0x7F,  // H
    0x00, 0x41, 0x7F, 0x41, 0x00,  // I
    0x20, 0x40, 0x41, 0x3F, 0x01,  // J
    0x7F, 0x08, 0x14, 0x22, 0x41,  // K
    0x7F, 0x40, 0x40, 0x40, 0x40,  // L
    0x7F, 0x02, 0x1C, 0x02, 0x7F,  // M
    0x7F, 0x04, 0x08, 0x10, 0x7F,  // N
    0x3E, 0x41, 0x41, 0x41, 0x3E,  // O
    0x7F, 0x09, 0x09, 0x09, 0x06,  // P
    0x3E, 0x41, 0x51, 0x21, 0x5E,  // Q
    0x7F, 0x09, 0x19, 0x29, 0x46,  // R
    0x26, 0x49, 0x49, 0x49, 0x32,  // S
    0x03, 0x01, 0x7F, 0x01, 0x03,  // T
    0x3F, 0x40, 0x40, 0x40, 0x3F,  // U
    0x1F, 0x20, 0x40, 0x20, 0x1F,  // V
    0x3F, 0x40, 0x38, 0x40, 0x3F,  // W
    0x63, 0x14, 0x08, 0x14, 0x63,  // X
    0x03, 0x04, 0x78, 0x04, 0x03,  // Y
    0x61, 0x59, 0x49, 0x4D, 0x43,  // Z
    0x00, 0x7F, 0x41, 0x41, 0x41,  // [
    0x02, 0x04, 0x08, 0x10, 0x20,  // dau gach nguoc
    0x00, 0x41, 0x41, 0x41, 0x7F,  // ]
    0x04, 0x02, 0x01, 0x02, 0x04,  // ^
    0x40, 0x40, 0x40, 0x40, 0x40,  // _
    0x00, 0x03, 0x07, 0x08, 0x00,  // `
    0x20, 0x54, 0x54, 0x78, 0x40,  // a
    0x7F, 0x28, 0x44, 0x44, 0x38,  // b
    0x38, 0x44, 0x44, 0x44, 0x28,  // c
    0x38, 0x44, 0x44, 0x28, 0x7F,  // d
    0x38, 0x54, 0x54, 0x54, 0x18,  // e
    0x00, 0x08, 0x7E, 0x09, 0x02,  // f
    0x18, 0xA4, 0xA4, 0x9C, 0x78,  // g
    0x7F, 0x08, 0x04, 0x04, 0x78,  // h
    0x00, 0x44, 0x7D, 0x40, 0x00,  // i
    0x20, 0x40, 0x40, 0x3D, 0x00,  // j
    0x7F, 0x10, 0x28, 0x44, 0x00,  // k
    0x00, 0x41, 0x7F, 0x40, 0x00,  // l
    0x7C, 0x04, 0x78, 0x04, 0x78,  // m
    0x7C, 0x08, 0x04, 0x04, 0x78,  // n
    0x38, 0x44, 0x44, 0x44, 0x38,  // o
    0xFC, 0x18, 0x24, 0x24, 0x18,  // p
    0x18, 0x24, 0x24, 0x18, 0xFC,  // q
    0x7C, 0x08, 0x04, 0x04, 0x08,  // r
    0x48, 0x54, 0x54, 0x54, 0x24,  // s
    0x04, 0x04, 0x3F, 0x44, 0x24,  // t
    0x3C, 0x40, 0x40, 0x20, 0x7C,  // u
    0x1C, 0x20, 0x40, 0x20, 0x1C,  // v
    0x3C, 0x40, 0x30, 0x40, 0x3C,  // w
    0x44, 0x28, 0x10, 0x28, 0x44,  // x
    0x4C, 0x90, 0x90, 0x90, 0x7C,  // y
    0x44, 0x64, 0x54, 0x4C, 0x44,  // z
    0x00, 0x08, 0x36, 0x41, 0x00,  // {
    0x00, 0x00, 0x77, 0x00, 0x00,  // |
    0x00, 0x41, 0x36, 0x08, 0x00,  // }
    0x02, 0x01, 0x02, 0x04, 0x02,  // ~
};

// Gui 1 chuoi lenh (control byte 0x00)
static inline esp_err_t oled_send_cmds(oled_t *o, const uint8_t *cmds, size_t len)
{
    const uint8_t ctrl = 0x00;
    I2C_DEV_TAKE_MUTEX(&o->dev);
    I2C_DEV_CHECK(&o->dev, i2c_dev_write(&o->dev, &ctrl, 1, cmds, len));
    I2C_DEV_GIVE_MUTEX(&o->dev);
    return ESP_OK;
}

static inline void oled_clear(oled_t *o)
{
    memset(o->buf, 0, sizeof(o->buf));
}

// Day bo nho dem ra man hinh (tung dong mot)
static inline esp_err_t oled_flush(oled_t *o)
{
    for (int page = 0; page < OLED_LINES; page++) {
        const uint8_t set_pos[3] = { (uint8_t)(0xB0 | page), 0x00, 0x10 };   // chon dong, cot 0
        esp_err_t err = oled_send_cmds(o, set_pos, sizeof(set_pos));
        if (err != ESP_OK) {
            return err;
        }

        const uint8_t ctrl = 0x40;   // control byte 0x40 = du lieu hien thi
        I2C_DEV_TAKE_MUTEX(&o->dev);
        I2C_DEV_CHECK(&o->dev, i2c_dev_write(&o->dev, &ctrl, 1, &o->buf[page * OLED_WIDTH], OLED_WIDTH));
        I2C_DEV_GIVE_MUTEX(&o->dev);
    }
    return ESP_OK;
}

// Khoi tao man hinh. addr thuong la 0x3C (mot so module la 0x3D)
static inline esp_err_t oled_init(oled_t *o, uint8_t addr, i2c_port_t port, gpio_num_t sda, gpio_num_t scl)
{
    memset(o, 0, sizeof(*o));
    o->dev.port = port;
    o->dev.addr = addr;
    o->dev.cfg.sda_io_num = sda;
    o->dev.cfg.scl_io_num = scl;
    o->dev.cfg.master.clk_speed = 400000;

    esp_err_t err = i2c_dev_create_mutex(&o->dev);
    if (err != ESP_OK) {
        return err;
    }

    static const uint8_t init_seq[] = {
        0xAE,         // tat hien thi
        0xD5, 0x80,   // toc do clock
        0xA8, 0x3F,   // multiplex 64 dong
        0xD3, 0x00,   // khong dich man hinh
        0x40,         // dong bat dau = 0
        0x8D, 0x14,   // bat charge pump (bat buoc voi module 0.96 inch)
        0x20, 0x02,   // che do dia chi theo page
        0xA1,         // dao chieu cot (doi thanh 0xA0 neu chu bi lat guong)
        0xC8,         // dao chieu dong (doi thanh 0xC0 neu chu bi lon nguoc)
        0xDA, 0x12,   // cau hinh chan COM
        0x81, 0xCF,   // do tuong phan
        0xD9, 0xF1,   // pre-charge
        0xDB, 0x40,   // muc VCOMH
        0xA4,         // hien thi theo bo nho
        0xA6,         // hien thi binh thuong (khong dao mau)
        0xAF          // bat hien thi
    };
    err = oled_send_cmds(o, init_seq, sizeof(init_seq));
    if (err != ESP_OK) {
        return err;
    }

    oled_clear(o);
    return oled_flush(o);
}

// Ve 1 ky tu tai o (col, line)
static inline void oled_put_char(oled_t *o, int col, int line, char c)
{
    if (col < 0 || col >= OLED_COLS || line < 0 || line >= OLED_LINES) {
        return;
    }
    if (c < 32 || c > 126) {
        c = '?';
    }
    uint8_t *dst = &o->buf[line * OLED_WIDTH + col * 6];
    memcpy(dst, &OLED_FONT_5X7[(c - 32) * 5], 5);
    dst[5] = 0x00;   // cot trong giua 2 ky tu
}

// Ghi chuoi tai (col, line)
static inline void oled_print(oled_t *o, int col, int line, const char *text)
{
    for (; *text && col < OLED_COLS; text++, col++) {
        oled_put_char(o, col, line, *text);
    }
}

// Xoa 1 dong roi ghi noi dung moi theo dinh dang printf
static inline void oled_printf(oled_t *o, int line, const char *fmt, ...) __attribute__((format(printf, 3, 4)));
static inline void oled_printf(oled_t *o, int line, const char *fmt, ...)
{
    if (line < 0 || line >= OLED_LINES) {
        return;
    }
    char text[OLED_COLS + 1];
    va_list args;
    va_start(args, fmt);
    vsnprintf(text, sizeof(text), fmt, args);
    va_end(args);

    memset(&o->buf[line * OLED_WIDTH], 0, OLED_WIDTH);
    oled_print(o, 0, line, text);
}
